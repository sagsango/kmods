## 09-rust-hello-world/Kconfig
```kconfig
config HELLO_WORLD
    tristate "Rust Hello World Kernel Module"
    depends on RUST
```
